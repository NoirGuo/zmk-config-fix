## boards/shields/hpd/Kconfig.shield
```kconfig
config SHIELD_HPD_LEFT
    def_bool $(shields_list_contains,hpd_left)

config SHIELD_HPD_RIGHT
    def_bool $(shields_list_contains,hpd_right)
```
